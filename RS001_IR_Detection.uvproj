# Keil uVision project RS001_IR_Detection.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: RS001_IR_Detection +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c user_led.c user_adc.c user_timer.c user_motor.c user_exti.c
